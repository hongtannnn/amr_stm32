<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\amr_pi_stm32f405rgt6.ewp</path>
  </project>
  <batchBuild />
</workspace>
